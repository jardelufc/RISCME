# Keil uVision project mycm0code.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.4.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: mycm0code
  AfterMake: fromelf -cvf Objects\mycm0code.axf -o disasm.txt --vhx --16x1 -o mycm0code.hex
  AfterMake: fromelf -cvf Objects\mycm0code.axf -o disasm.txt --vhx --32x1 -o mycm0code32.hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group Source Group 1
    ./: blinkriscme.s
